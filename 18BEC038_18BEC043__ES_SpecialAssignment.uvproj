# Keil uVision project 18BEC038_18BEC043__ES_SpecialAssignment.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: 18BEC038_18BEC043__ES_SpecialAssignment +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 18BEC038_18BEC043__ES_SpecialAssignment.c
